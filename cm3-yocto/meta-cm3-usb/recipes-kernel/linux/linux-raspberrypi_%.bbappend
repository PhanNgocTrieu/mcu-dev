FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://connectivity-usb.cfg"
